# VSOCK Makefile has no install goal, yet the recipe tries to call it
PACKAGECONFIG = ""