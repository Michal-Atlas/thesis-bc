# RDEPENDS:${PN}:append = " python3-scipy"
